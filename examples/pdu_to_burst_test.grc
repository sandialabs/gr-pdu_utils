<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pdu_to_burst_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data0</value></param>
<param><key>value</key><value>pmt.init_c32vector(1000, range(0,1000))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data1</value></param>
<param><key>value</key><value>pmt.init_c32vector(1000, range(1000, 0, -1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meta</value></param>
<param><key>value</key><value>pmt.dict_add(pmt.make_dict(), pmt.intern('tx_time'), pmt.from_uint64(12345))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>period</value></param>
<param><key>value</key><value>52/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.cons(meta,data0)</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.make_dict(),data1)</value></param>
<param><key>period</key><value>period * 1.3</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.cons(meta,data1)</value></param>
<param><key>period</key><value>period * 1.3</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pdu_utils_pdu_to_bursts_X</key>
<param><key>id</key><value>pdu_utils_pdu_to_bursts_X_0</value></param>
<param><key>early_behavior</key><value>0</value></param>
<param><key>type</key><value>c</value></param>
<param><key>depth</key><value>128</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>int(samp_rate*0.97)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1500</value></param>
<param><key>ymin</key><value>-500</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>pdu_utils_pdu_to_bursts_X_0</sink_block_id><source_key>strobe</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>pdu_utils_pdu_to_bursts_X_0</sink_block_id><source_key>strobe</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0_0</source_block_id><sink_block_id>pdu_utils_pdu_to_bursts_X_0</sink_block_id><source_key>strobe</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_to_bursts_X_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
