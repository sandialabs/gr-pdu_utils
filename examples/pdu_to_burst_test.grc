options:
  parameters:
    generate_options: qt_gui
    id: pdu_to_burst_test
    output_language: python
  states: {}

blocks:
- name: data0
  id: variable
  parameters:
    value: pmt.init_c32vector(1000, range(0,1000))
  states: {}
- name: data1
  id: variable
  parameters:
    value: pmt.init_c32vector(1000, range(1000, 0, -1))
  states: {}
- name: meta
  id: variable
  parameters:
    value: pmt.dict_add(pmt.make_dict(), pmt.intern('tx_time'), pmt.from_uint64(12345))
  states: {}
- name: period
  id: variable
  parameters:
    value: 52/4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(meta,data0)
    period: period
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(),data1)
    period: int(period * 1.3)
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(meta,data1)
    period: period * 1.3
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pdu_utils_pdu_to_bursts_X_0
  id: pdu_utils_pdu_to_bursts_X
  parameters:
    depth: '128'
    early_behavior: pdu_utils.EARLY_BURST_BEHAVIOR__APPEND
    type: c
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: int(samp_rate*0.97)
    srate: '1'
    type: complex
    ymax: '1500'
    ymin: '-500'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_utils_pdu_to_bursts_X_0, bursts]
- [blocks_message_strobe_0_0, strobe, pdu_utils_pdu_to_bursts_X_0, bursts]
- [blocks_message_strobe_0_0_0, strobe, pdu_utils_pdu_to_bursts_X_0, bursts]
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [pdu_utils_pdu_to_bursts_X_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
